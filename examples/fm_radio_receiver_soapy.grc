options:
  parameters:
    generate_options: qt_gui
    id: fm_radio_receiver_soapy
    output_language: python
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,3,1,3
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '2'
    stop: '60'
    value: '6'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: audio_rate*8
  states: {}
- name: radio_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,3
    label: Center Frequency
    type: real
    value: 95.7e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: vol
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,3
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.05'
    stop: '1.5'
    value: '0.3'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: int(quad_rate/audio_rate)
    comment: Quadrature rate is the input rate
    quad_rate: quad_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 60e3
    decim: int(samp_rate/quad_rate)
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: radio_freq
    fftsize: '1024'
    gui_hint: 2,0,2,3
    name: '"Input"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-90'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    fc: radio_freq
    fftsize: '1024'
    gui_hint: 2,3,2,3
    name: Audio
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-90'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: radio_freq
    fftsize: '1024'
    gui_hint: 4,0,2,3
    int_min: '-80'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    ant0: RX2
    ant1: ''
    balance0: '0'
    center_freq0: radio_freq
    correction0: '0'
    dc_offset0: '0'
    dc_offset_auto_mode0: 'False'
    dc_offset_auto_mode1: 'False'
    devname: rtlsdr
    lna_gain0: '0'
    manual_gain0: 'True'
    manual_gain1: 'True'
    mix_gain0: '0'
    mix_gain1: '10'
    overall_gain0: '0'
    pga_gain0: '0'
    samp_rate: samp_rate
    sdrplay_biastee: 'True'
    tuner_gain0: gain
    tuner_gain1: '10'
    type: fc32
    vga_gain0: '0'
    vga_gain1: '10'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [soapy_source_0, '0', low_pass_filter_0, '0']
- [soapy_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
