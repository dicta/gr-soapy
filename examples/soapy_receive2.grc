options:
  parameters:
    generate_options: qt_gui
    id: soapy_rcv2
    output_language: python
    title: SOAPY Receive Test
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 905e6
  states: {}
- name: gain1
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Gain1
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '15'
    value: '0'
  states: {}
- name: gain2
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Gain2
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '15'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 1,0,1,2
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 2,0,1,2
    int_max: '-10'
    int_min: '-80'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    ant0: ''
    ant1: ''
    balance0: '0'
    center_freq0: freq
    correction0: '0'
    dc_offset0: '0'
    dc_offset_auto_mode0: 'False'
    dc_offset_auto_mode1: 'False'
    dev: driver=airspy
    devname: airspy
    fine_tune0: 'True'
    fine_tune1: 'True'
    mix_gain0: gain2
    mix_gain1: '10'
    overall_gain0: '10'
    samp_rate: samp_rate
    sdrplay_biastee: 'true'
    sdrplay_dabnotch: 'false'
    sdrplay_rfnotch: 'false'
    tuner_gain1: '10'
    type: fc32
    vga_gain0: gain1
    vga_gain1: '10'
  states: {}

connections:
- [soapy_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
