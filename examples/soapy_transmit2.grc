options:
  parameters:
    generate_options: qt_gui
    id: soapy_xmit2
    output_language: python
    title: Soapy Test Transmit
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 905e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    orient: Qt.Horizontal
    start: '0'
    step: '2'
    stop: '62'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: xmit_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /opt/sdr/gnuradio/gnuradio_recordings/NOAA_weather_radio_162.425MHz_NBFM_600KSPS_48KFilter.iq
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: xmit_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 1,0,1,2
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: xmit_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 2,0,1,2
    int_max: '-10'
    int_min: '-80'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(xmit_rate/samp_rate)
    taps: ''
    type: ccc
  states: {}
- name: soapy_sink_0
  id: soapy_sink
  parameters:
    amp_gain0: '14'
    ant0: TX/RX
    ant1: ''
    center_freq0: freq
    dev: driver=hackrf
    devname: hackrf
    pga_gain0: gain
    samp_rate: xmit_rate
    type: fc32
    vga_gain0: gain
  states: {}

connections:
- [blocks_file_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', soapy_sink_0, '0']

metadata:
  file_format: 1
